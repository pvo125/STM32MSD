# Keil uVision project STM32USBDevice.uvproj, settings and files
target STM32USBDevice (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32USBDevice +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\STM32F10x_StdPeriph_Driver\src;..\STM32F10x_StdPeriph_Driver\inc;..\USER\main;..\USER\SDCARD;..\USER\USB;..\USER\USB\BOT;..\USER\USB\inc;..\CMSIS\DeviceSupport\ST\STM32F10x;..\CMSIS\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x5000
  group Startup
    ../CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c
  group main
    ../USER/main/: main.c stm32f10x_it.c
  group USB
    ../USER/USB/: usb.c usb_desc.c usb_regs.c
    ../USER/USB/BOT/: bot.c scsi.c
  group SDCARD
    ../USER/SDCARD/: sdcard.c my_sdcard.c
